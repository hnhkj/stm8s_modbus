# IAR project Project.ewp, settings and files
configuration STM8S003 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\modbus\include; ..\modbus\ascii; ..\modbus\rtu; ..\modbus\tcp; ..\port
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: README.md
  group FreeModbus
    ../modbus/: mb.c
    ../modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
    ../modbus/ascii/: mbascii.c mbascii.h
    ../modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../modbus/tcp/: mbtcp.c mbtcp.h
  group StdPeriph_Drivers
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_spi.c stm8s_tim4.c stm8s_uart1.c
  group User
    ../: main.c stm8s_it.c
    ../port/: port.h portevent.c portserial.c porttimer.c
